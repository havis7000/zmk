## app/boards/shields/TK013/Kconfig.shield
```kconfig
# Copyright (c) 2022 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_TK013
  def_bool $(shields_list_contains,tk013)
```
